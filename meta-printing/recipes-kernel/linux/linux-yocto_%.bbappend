FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://usbip.cfg"
